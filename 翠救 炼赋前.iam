# Autodesk Inventor assembly: 답안 조립품
## iProperties
Created: 2014-11
Part Number: 답안 조립품
Document SubType Name: Assembly
Designer: elite
Author: elite
